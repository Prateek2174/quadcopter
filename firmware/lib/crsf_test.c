int main(void) {

    crsf_frame_t p;
    crsf_init(&p);

    //test frame
    const uint8_t frame[26] = {
        0xC8, 0x18, 0x16, 0xAC, 0x98, 0x38, 0x77, 0xE9, 0x33, 0x71,
        0xF0, 0x81, 0x0F, 0x7C, 0xE0, 0x03, 0x1F, 0xF8, 0xC0, 0x07,
        0x3E, 0xF0, 0x81, 0x0F, 0x7C, 0x7F
    };

    const uint8_t bad_frame[26] = {
        0xC8, 0x18, 0x16, 0xAC, 0x98, 0x38, 0x77, 0xE9, 0x33, 0x71,
        0xF1, 0x81, 0x0F, 0x7C, 0xE0, 0x03, 0x1F, 0xF8, 0xC0, 0x07,
        0x3E, 0xF0, 0x81, 0x0F, 0x7C, 0x7F
    };

    const uint8_t stream[67] = {
        0x00, 0xFF, 0xC8, 0x40, 0x12,
        0xC8, 0x18, 0x16, 0xAC, 0x98, 0x38, 0x77, 0xE9, 0x33, 0x71,
        0xF0, 0x81, 0x0F, 0x7C, 0xE0, 0x03, 0x1F, 0xF8, 0xC0, 0x07,
        0x3E, 0xF0, 0x81, 0x0F, 0x7C, 0x7F,
        0xC8, 0x18, 0x16, 0xAC, 0x98, 0x38, 0x77, 0xE9, 0x33, 0x71,
        0xC8, 0x18, 0x16, 0xAC, 0x98, 0x38, 0x77, 0xE9, 0x33, 0x71,
        0xF0, 0x81, 0x0F, 0x7C, 0xE0, 0x03, 0x1F, 0xF8, 0xC0, 0x07,
        0x3E, 0xF0, 0x81, 0x0F, 0x7C, 0x7F
    };

    int count = 0;

    for (size_t i = 0; i < sizeof(stream); i++) 
    {
        if(crsf_byte_handler(&p, stream[i]))
        {
            count++;
            printf("%zu \n", i);

            payload_to_channel(&p);

            for (size_t j = 0; j < 16; j++)
            {
                printf("channel %zu = %u \n", j, p.channels[j]);
            }
            
        }
        
    }

    printf("number of good frames = %d", count);
    

    return 0;

}
## linux/package/telemetry-bridge/Config.in
```kconfig
config BR2_PACKAGE_TELEMETRY_BRIDGE
	bool "telemetry-bridge"
	help
	  UART bridge between the STM32 flight controller and Linux.
```
